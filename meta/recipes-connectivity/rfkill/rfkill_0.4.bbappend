FILESEXTRAPATHS := "${THISDIR}/files"
SRC_URI += "file://0002-version-sh-remove-git-detection.patch"

